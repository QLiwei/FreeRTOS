# Keil uVision project Template_GD32F30x.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template_GD32F30x +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_XD
  c include: ..\Libraries\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS\GD\GD32F30x\Include;..\Libraries\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS;..\Libraries\GD32F30x_Firmware_Library_V2.1.3\Firmware\GD32F30x_standard_peripheral\Include;..\User;..\BSP;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../User/: main.c systick.c
  group BSP
    ../BSP/: debug_usart.c bsp.c
  group MDK_ARM
    ../Libraries/GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group CMSIS
    ../Libraries/GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Driver
    ../Libraries/GD32F30x_Firmware_Library_V2.1.3/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group FreeRTOS/Source
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
